Commit message: Rename to the demo imu name_space.

File: urdf/olv-imu01.urdf (robot description, URDF)
Before this commit: robot olv-srv01-robot, 1 links, 0 joints
Links:
- removed link base_link
- added link olive
